# Keil uVision project NEU_Group05_Task.uvprojx, settings and files
target NEU_Group05_Task (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: NEU_Group05_Task +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,ARM_MATH_CM4
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/RTOS2/Include;../Drivers/CMSIS/DSP/Include;../Drivers/MAX30102;../Drivers/SH3001;../Drivers/CMSIS/DSP/PrivateInclude;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../TouchGFX/App;../TouchGFX/target/generated;../TouchGFX/target;../Drivers/TOUCH;../middlewares/st/touchgfx/framework/include;../touchgfx/generated/fonts/include;../touchgfx/generated/gui_generated/include;../touchgfx/generated/images/include;../touchgfx/generated/texts/include;../touchgfx/generated/videos/include;../touchgfx/gui/include
  asm include: ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: key.c ad8232.c delay.c app_sensor_service.c app_i2c_bus.c app_buzzer_service.c app_alarm_service.c app_light_service.c buzzer.c bp_service.c main.c gpio.c freertos.c adc.c crc.c dma2d.c fmc.c i2c.c ltdc.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma2d.c stm32f4xx_ll_fmc.c stm32f4xx_hal_nor.c stm32f4xx_hal_sram.c stm32f4xx_hal_nand.c stm32f4xx_hal_pccard.c stm32f4xx_hal_sdram.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/MAX30102
    ../Drivers/MAX30102/: max30102.c max30102_fir.c algorithm.c
  group CMSIS_DSP_Filtering
    ../Drivers/CMSIS/DSP/Source/FilteringFunctions/: arm_fir_f32.c arm_fir_init_f32.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Application/User/TouchGFX/target
    ../TouchGFX/target/: TouchGFXHAL.cpp STM32TouchController.cpp TouchGFXGPIO.cpp
  group Application/User/TouchGFX/target/generated
    ../TouchGFX/target/generated/: TouchGFXConfiguration.cpp TouchGFXGeneratedHAL.cpp STM32DMA.cpp OSWrappers.cpp
  group Application/User/TouchGFX/App
    ../TouchGFX/App/: app_touchgfx.c
  group gui
    ../touchgfx/gui/src/bloodpressurescreen_screen/: bloodpressurescreenpresenter.cpp bloodpressurescreenview.cpp
    ../touchgfx/gui/src/ecgscreen_screen/: ecgscreenpresenter.cpp ecgscreenview.cpp
    ../touchgfx/gui/src/common/: frontendapplication.cpp
    ../touchgfx/gui/src/homescreen_screen/: homescreenpresenter.cpp homescreenview.cpp
    ../touchgfx/gui/src/imuscreen_screen/: imuscreenpresenter.cpp imuscreenview.cpp
    ../touchgfx/gui/src/ledscreen_screen/: ledscreenpresenter.cpp ledscreenview.cpp
    ../touchgfx/gui/src/model/: model.cpp
    ../touchgfx/gui/src/pulsescreen_screen/: pulsescreenpresenter.cpp pulsescreenview.cpp
  group generated
    ../touchgfx/generated/fonts/src/: applicationfontprovider.cpp cachedfont.cpp font_verdana_10_4bpp_0.cpp font_verdana_20_4bpp_0.cpp font_verdana_26_4bpp_0.cpp font_verdana_40_4bpp_0.cpp font_vinet_29_4bpp_0.cpp fontcache.cpp generatedfont.cpp kerning_verdana_10_4bpp.cpp kerning_verdana_20_4bpp.cpp kerning_verdana_26_4bpp.cpp kerning_verdana_40_4bpp.cpp kerning_vinet_29_4bpp.cpp table_verdana_10_4bpp.cpp table_verdana_20_4bpp.cpp table_verdana_26_4bpp.cpp table_verdana_40_4bpp.cpp table_vinet_29_4bpp.cpp unmappeddatafont.cpp
    ../touchgfx/generated/images/src/: bitmapdatabase.cpp svgdatabase.cpp
    ../touchgfx/generated/gui_generated/src/bloodpressurescreen_screen/: bloodpressurescreenviewbase.cpp
    ../touchgfx/generated/gui_generated/src/ecgscreen_screen/: ecgscreenviewbase.cpp
    ../touchgfx/generated/gui_generated/src/common/: frontendapplicationbase.cpp
    ../touchgfx/generated/gui_generated/src/homescreen_screen/: homescreenviewbase.cpp
    ../touchgfx/generated/images/src/__generated/: image_alternate_theme_images_widgets_button_regular_height_36_medium_round_action.cpp image_alternate_theme_images_widgets_button_regular_height_36_medium_round_pressed.cpp image_alternate_theme_images_widgets_button_regular_height_50_medium_round_action.cpp image_alternate_theme_images_widgets_button_regular_height_50_medium_round_pressed.cpp image_alternate_theme_images_widgets_button_regular_height_50_tiny_round_disabled.cpp image_clay_theme_images_widgets_button_regular_height_36_large_rounded_action.cpp image_clay_theme_images_widgets_button_regular_height_36_large_rounded_pressed.cpp image_dark_theme_images_widgets_boxprogress_thick_large.cpp image_icon_theme_images_action_accessible_forward_50_50_000000.svg.cpp
    ../touchgfx/generated/gui_generated/src/imuscreen_screen/: imuscreenviewbase.cpp
    ../touchgfx/generated/texts/src/: languagegb.cpp texts.cpp typedtextdatabase.cpp
    ../touchgfx/generated/gui_generated/src/ledscreen_screen/: ledscreenviewbase.cpp
    ../touchgfx/generated/gui_generated/src/pulsescreen_screen/: pulsescreenviewbase.cpp
  group Lib
    ../middlewares/st/touchgfx/lib/core/cortex_m4f/Keil/: touchgfx_core.lib
  group Drivers/SH3001
    ../Drivers/SH3001/: sh3001.c
  group Drivers/TOUCH
    ../Drivers/TOUCH/: ctiic.c gt9xxx.c
software components: CMSIS:CORE 4.3.0
